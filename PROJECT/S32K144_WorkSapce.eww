<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\S32K144_BUILD.ewp</path>
  </project>
  <batchBuild/>
</workspace>


