# IAR project S32K144_BUILD.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_S32K144HFT0VLLT; S32K
  ICCARM.CCIncludePath2: ..\SOURCE\FreeRTOS\include; ..\SOURCE\FreeRTOS\portable\IAR\ARM_CM4F; ..\SOURCE\APPLICATIONS\CAN_FBL; ..\SOURCE\PLATFORM\devices; ..\SOURCE\PLATFORM\hal\inc; ..\SOURCE\PLATFORM\drivers\inc; ..\SOURCE\SERVICES\OSEK_NM; ..\SOURCE; ..\SOURCE\PLATFORM; ..\SOURCE\APPLICATIONS\CAN_FBL; ..\SOURCE\APPLICATIONS\AVAS_ECU; ..\SOURCE\COMMON; ..\SOURCE\SERVICES; ..\SOURCE\SERVICES\UDS; ..\SOURCE\APPLICATIONS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: S32K144_BUILD.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\SOURCE\PLATFORM\devices\S32K144\linker\iar\S32K144_100_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: EntryPoint.c
  group COMMON
    ../SOURCE/COMMON/: Includes.h
  group COMMON/TRACE
    ../SOURCE/COMMON/TRACE/: TRACE.c TRACE.h TRACE_Priv.h
  group PLATFORM
    ../SOURCE/PLATFORM/: BoardDefines.h canCom1.c canCom1.h clockMan1.c clockMan1.h Cpu.c Cpu.h FreeRTOSConfig.h pin_mux.c pin_mux.h PLATFORM.c PLATFORM.h PLATFORM_Priv.h
  group PLATFORM/devices
    ../SOURCE/PLATFORM/devices/: fsl_device_registers.h startup.c startup.h
  group PLATFORM/devices/S32K144/include
    ../SOURCE/PLATFORM/devices/S32K144/include/: S32K144.h S32K144_features.h
  group PLATFORM/devices/S32K144/linker/iar
    ../SOURCE/PLATFORM/devices/S32K144/linker/iar/: S32K144_100_flash.icf S32K144_100_ram.icf
  group PLATFORM/devices/S32K144/startup
    ../SOURCE/PLATFORM/devices/S32K144/startup/: system_S32K144.c system_S32K144.h
  group PLATFORM/devices/S32K144/startup/iar
    ../SOURCE/PLATFORM/devices/S32K144/startup/iar/: startup_S32K144.s
  group PLATFORM/drivers/inc
    ../SOURCE/PLATFORM/drivers/inc/: fsl_adc_driver.h fsl_clock_manager.h fsl_cmp_driver.h fsl_crc_driver.h fsl_edma_driver.h fsl_edma_request.h fsl_flash_driver_c90tfs.h fsl_flexcan_driver.h fsl_flexio_i2c_driver.h fsl_flexio_spi_driver.h fsl_ftm_driver.h fsl_interrupt_manager.h fsl_lin_driver.h fsl_lpi2c_driver.h fsl_lpit_driver.h fsl_lpspi_master_driver.h fsl_lpspi_shared_function.h fsl_lpspi_slave_driver.h fsl_lptmr_driver.h fsl_lpuart_driver.h fsl_mpu_driver.h fsl_pdb_driver.h fsl_pins_driver.h fsl_power_manager.h fsl_rtc_driver.h fsl_trgmux_driver.h fsl_wdog_driver.h
  group PLATFORM/drivers/src/adc
    ../SOURCE/PLATFORM/drivers/src/adc/: fsl_adc_driver.c
  group PLATFORM/drivers/src/clock
    ../SOURCE/PLATFORM/drivers/src/clock/: fsl_clock_manager.c
  group PLATFORM/drivers/src/clock/S32K144
    ../SOURCE/PLATFORM/drivers/src/clock/S32K144/: fsl_clock_S32K144.c fsl_clock_S32K144.h
  group PLATFORM/drivers/src/cmp
    ../SOURCE/PLATFORM/drivers/src/cmp/: fsl_cmp_driver.c
  group PLATFORM/drivers/src/crc
    ../SOURCE/PLATFORM/drivers/src/crc/: fsl_crc_driver.c
  group PLATFORM/drivers/src/edma
    ../SOURCE/PLATFORM/drivers/src/edma/: fsl_edma_common.c fsl_edma_driver.c fsl_edma_irq.c
  group PLATFORM/drivers/src/flash
    ../SOURCE/PLATFORM/drivers/src/flash/: fsl_flash_driver_c90tfs.c
  group PLATFORM/drivers/src/flexcan
    ../SOURCE/PLATFORM/drivers/src/flexcan/: fsl_flexcan_common.c fsl_flexcan_driver.c fsl_flexcan_irq.c
  group PLATFORM/drivers/src/flexio
    ../SOURCE/PLATFORM/drivers/src/flexio/: fsl_flexio_i2c_driver.c fsl_flexio_i2c_irq.c fsl_flexio_spi_driver.c fsl_flexio_spi_irq.c
  group PLATFORM/drivers/src/ftm
    ../SOURCE/PLATFORM/drivers/src/ftm/: fsl_ftm_common.c fsl_ftm_driver.c fsl_ftm_lpm_callback.c
  group PLATFORM/drivers/src/interrupt
    ../SOURCE/PLATFORM/drivers/src/interrupt/: fsl_interrupt_manager.c
  group PLATFORM/drivers/src/lin
    ../SOURCE/PLATFORM/drivers/src/lin/: fsl_lin_common.c fsl_lin_driver.c fsl_lin_irq.c fsl_lin_lpuart_driver.c fsl_lin_lpuart_driver.h
  group PLATFORM/drivers/src/lpi2c
    ../SOURCE/PLATFORM/drivers/src/lpi2c/: fsl_lpi2c_driver.c fsl_lpi2c_irq.c
  group PLATFORM/drivers/src/lpit
    ../SOURCE/PLATFORM/drivers/src/lpit/: fsl_lpit_common.c fsl_lpit_driver.c
  group PLATFORM/drivers/src/lpspi
    ../SOURCE/PLATFORM/drivers/src/lpspi/: fsl_lpspi_common.c fsl_lpspi_irq.c fsl_lpspi_master_driver.c fsl_lpspi_shared_function.c fsl_lpspi_slave_driver.c
  group PLATFORM/drivers/src/lptmr
    ../SOURCE/PLATFORM/drivers/src/lptmr/: fsl_lptmr_driver.c
  group PLATFORM/drivers/src/lpuart
    ../SOURCE/PLATFORM/drivers/src/lpuart/: fsl_lpuart_common.c fsl_lpuart_driver.c fsl_lpuart_irq.c
  group PLATFORM/drivers/src/mpu
    ../SOURCE/PLATFORM/drivers/src/mpu/: fsl_mpu_driver.c
  group PLATFORM/drivers/src/pdb
    ../SOURCE/PLATFORM/drivers/src/pdb/: fsl_pdb_common.c fsl_pdb_driver.c
  group PLATFORM/drivers/src/pins
    ../SOURCE/PLATFORM/drivers/src/pins/: fsl_pins_driver.c
  group PLATFORM/drivers/src/power
    ../SOURCE/PLATFORM/drivers/src/power/: fsl_power_manager.c
  group PLATFORM/drivers/src/rtc
    ../SOURCE/PLATFORM/drivers/src/rtc/: fsl_rtc_driver.c fsl_rtc_irq.c
  group PLATFORM/drivers/src/trgmux
    ../SOURCE/PLATFORM/drivers/src/trgmux/: fsl_trgmux_common.c fsl_trgmux_driver.c
  group PLATFORM/drivers/src/wdog
    ../SOURCE/PLATFORM/drivers/src/wdog/: fsl_wdog_driver.c
  group PLATFORM/hal/inc
    ../SOURCE/PLATFORM/hal/inc/: fsl_adc_hal.h fsl_cmp_hal.h fsl_crc_hal.h fsl_dmamux_hal.h fsl_edma_hal.h fsl_flexcan_hal.h fsl_flexio_hal.h fsl_ftm_hal.h fsl_gpio_hal.h fsl_lpi2c_hal.h fsl_lpit_hal.h fsl_lpspi_hal.h fsl_lptmr_hal.h fsl_lpuart_hal.h fsl_mpu_hal.h fsl_pcc_hal.h fsl_pdb_hal.h fsl_pmc_hal.h fsl_port_hal.h fsl_rcm_hal.h fsl_rtc_hal.h fsl_scg_hal.h fsl_sim_hal.h fsl_smc_hal.h fsl_trgmux_hal.h fsl_wdog_hal.h
  group PLATFORM/hal/src/adc
    ../SOURCE/PLATFORM/hal/src/adc/: fsl_adc_hal.c
  group PLATFORM/hal/src/cmp
    ../SOURCE/PLATFORM/hal/src/cmp/: fsl_cmp_hal.c
  group PLATFORM/hal/src/crc
    ../SOURCE/PLATFORM/hal/src/crc/: fsl_crc_hal.c
  group PLATFORM/hal/src/dmamux
    ../SOURCE/PLATFORM/hal/src/dmamux/: fsl_dmamux_hal.c
  group PLATFORM/hal/src/edma
    ../SOURCE/PLATFORM/hal/src/edma/: fsl_edma_hal.c
  group PLATFORM/hal/src/flexcan
    ../SOURCE/PLATFORM/hal/src/flexcan/: fsl_flexcan_hal.c
  group PLATFORM/hal/src/flexio
    ../SOURCE/PLATFORM/hal/src/flexio/: fsl_flexio_hal.c
  group PLATFORM/hal/src/ftm
    ../SOURCE/PLATFORM/hal/src/ftm/: fsl_ftm_hal.c
  group PLATFORM/hal/src/lpi2c
    ../SOURCE/PLATFORM/hal/src/lpi2c/: fsl_lpi2c_hal.c
  group PLATFORM/hal/src/lpit
    ../SOURCE/PLATFORM/hal/src/lpit/: fsl_lpit_hal.c
  group PLATFORM/hal/src/lpspi
    ../SOURCE/PLATFORM/hal/src/lpspi/: fsl_lpspi_hal.c
  group PLATFORM/hal/src/lptmr
    ../SOURCE/PLATFORM/hal/src/lptmr/: fsl_lptmr_hal.c
  group PLATFORM/hal/src/lpuart
    ../SOURCE/PLATFORM/hal/src/lpuart/: fsl_lpuart_hal.c
  group PLATFORM/hal/src/mpu
    ../SOURCE/PLATFORM/hal/src/mpu/: fsl_mpu_hal.c
  group PLATFORM/hal/src/pcc
    ../SOURCE/PLATFORM/hal/src/pcc/: fsl_pcc_hal.c
  group PLATFORM/hal/src/pdb
    ../SOURCE/PLATFORM/hal/src/pdb/: fsl_pdb_hal.c
  group PLATFORM/hal/src/pmc
    ../SOURCE/PLATFORM/hal/src/pmc/: fsl_pmc_hal.c
  group PLATFORM/hal/src/port
    ../SOURCE/PLATFORM/hal/src/port/: fsl_port_hal.c
  group PLATFORM/hal/src/rcm
    ../SOURCE/PLATFORM/hal/src/rcm/: fsl_rcm_hal.c
  group PLATFORM/hal/src/rtc
    ../SOURCE/PLATFORM/hal/src/rtc/: fsl_rtc_hal.c
  group PLATFORM/hal/src/scg
    ../SOURCE/PLATFORM/hal/src/scg/: fsl_scg_hal.c
  group PLATFORM/hal/src/sim/S32K144
    ../SOURCE/PLATFORM/hal/src/sim/S32K144/: fsl_sim_hal_S32K144.c fsl_sim_hal_S32K144.h
  group PLATFORM/hal/src/smc
    ../SOURCE/PLATFORM/hal/src/smc/: fsl_smc_hal.c
  group PLATFORM/hal/src/trgmux
    ../SOURCE/PLATFORM/hal/src/trgmux/: fsl_trgmux_hal.c
  group PLATFORM/hal/src/wdog
    ../SOURCE/PLATFORM/hal/src/wdog/: fsl_wdog_hal.c
  group SERVICES/CAN_IF
    ../SOURCE/SERVICES/CAN_IF/: CAN_IF.c CAN_IF.h CAN_IF_Priv.h
